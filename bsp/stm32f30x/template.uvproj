# Keil uVision project template.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F302VC STMicroelectronics
  cpu: IRAM(0x20000000-0x200077FF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x7800
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: .\stm32f3xx.sct
